# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Bsp\Libraries\FWLIB\inc;..\Bsp\Libraries\CORE;..\Bsp\Libraries\SYSTEM;..\Bsp\System\delay;..\Bsp\System\sys;..\Bsp\System\usart;..\Bsp\Libraries\SYSTEM;..\Bsp\Drivers\LCD;..\Bsp\Drivers\USBVCP;..\Bsp\Libraries\USBLIB\STM32_USB_Device_Library\Class\cdc;..\Bsp\Libraries\USBLIB\STM32_USB_Device_Library\Core;..\Bsp\Libraries\USBLIB\STM32_USB_APP\USB_Device_Examples\VCP;..\Bsp\Libraries\USBLIB\STM32_USB_OTG_Driver;..\Bsp\Peripheral\LCD;..\Bsp\Drivers\adc;..\Project;..\Bsp\System\project_config
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/main/: main.c
    ../Bsp/System/project_config/: project_confi.c
  group Drivers
    ../Bsp/Drivers/USBVCP/: Driver_USBVCP.c
    ../Bsp/Peripheral/LCD/: lcd.c
    ../Bsp/Drivers/adc/: bsp_adc.c
  group CMSIS
    ../Bsp/Libraries/CORE/: startup_stm32f40_41xxx.s
    ../Bsp/Libraries/SYSTEM/: stm32f4xx_it.c system_stm32f4xx.c
  group Libraries
    ../Bsp/Libraries/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_dma.c
  group System
    ../Bsp/System/delay/: delay.c
    ../Bsp/System/sys/: sys.c
    ../Bsp/System/usart/: usart.c
  group USBLIB
    ../Bsp/Libraries/USBLIB/STM32_USB_Device_Library/Core/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../Bsp/Libraries/USBLIB/STM32_USB_OTG_Driver/: usb_core.c usb_dcd.c usb_dcd_int.c
